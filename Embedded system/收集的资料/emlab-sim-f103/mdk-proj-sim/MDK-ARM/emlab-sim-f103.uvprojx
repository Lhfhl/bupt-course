# Keil uVision project emlab-sim-f103.uvprojx, settings and files
target emlab-sim-f103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: emlab-sim-f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\..\lab-src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group lab-src
    ../../lab-src/kern/: app_fsm4.c app_n103.c board_fsm4.c board_itm.c board_qemu.c debug.c heap.c ios_device.c ios_fd.c kern_init.c kern_port_cm3.c kern_port_cm3_ccarm.c kern_port_cm3_gnu.c kern_test.c kshell.c kshell_cmd.c ktest.c msgq.c mutex.c pipe.c semaphore.c task.c timer.c
    ../../lab-src/project1/: project1_main.c syscall.c syscall_ccarm.S
    ../../lab-src/project2/: button_scan.c gpio_ops.c project2_main.c
    ../../lab-src/project3/: kfifo.c project3_main.c
    ../../lab-src/project4/: beep.c button.c decode.c key.c led.c pin_device.c pin_driver.c player.c project4_main.c pwm_device.c pwm_driver.c
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
